# Keil uVision project E063.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407ZE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.4
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: E063 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c include: ..\CMSIS\GD\GD32F4xx\Include;..\GD32F4xx_standard_peripheral\Include;..\CMSIS;..\CMSIS\GD\GD32F4xx\Source\ARM;..\Use\In
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../GD32F4xx_standard_peripheral/: gd32f4xx_it.c systick.c
  group bsp
    ../Use/: bsp_gpio.c bsp_uart.c bsp_can.c bsp_adc.c bsp_time.c bsp_spi.c
  group lib
    ../GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_can.c gd32f4xx_adc.c gd32f4xx_spi.c gd32f4xx_dbg.c gd32f4xx_misc.c gd32f4xx_dma.c gd32f4xx_timer.c
  group app
    ../Use/: app_CanDatQueue.c app_CanMessage.c app_AdcPower.c app_GpioSensor.c app_MotorConfig.c app_MotorStep.c app_drv8462.c app_mps6602.c app.Drv8424.c
  group main
    ../Use/: main.c
